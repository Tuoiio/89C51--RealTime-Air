# Keil uVision project DS1307.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1307 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c ds1307.c i2c.c lcd20x4.c dht22.c
